# Keil uVision project CB689.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC51F2832 silan
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0x7FFF) CLOCK(2000000) MODP2
  output: CB589P
  c flags: Optimize=6 SizeSpeed=1
  c include: G:\CB589P
  group Source Group 1
    ./: main.c system.c at24c08.c uart.c BK4802.c lcdset.c vco.c Menu.c key.c MenuEvent.c memory.c lcdshow.c handler.c
  group APP
    ./: iic.c
